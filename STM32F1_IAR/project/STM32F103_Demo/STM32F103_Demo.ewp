# IAR project STM32F103_Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\stm32f10x_stdlib\inc; ..\..\user; ..\..\cmsis\startup; ..\..\mt\mt_app; ..\..\mt\mt_alogrithm; ..\..\mt\mt_config; ..\..\mt\mt_drv; ..\..\mt\mt_drv\module; ..\..\mt\mt_drv\module\APDS_9960; ..\..\mt\mt_drv\module\LSM6DSL; ..\..\mt\mt_event; ..\..\mt\mt_hal; ..\..\mt\mt_lib; ..\..\mt\mt_util
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; _DLIB_FILE_DESCRIPTOR
  AARM.AUserIncludes: ..\..\stm32f10x_stdlib\inc; ..\..\user; ..\..\cmsis\startup; ..\..\mt\mt_app; ..\..\mt\mt_alogrithm; ..\..\mt\mt_config; ..\..\mt\mt_drv; ..\..\mt\mt_event; ..\..\mt\mt_hal; ..\..\mt\mt_lib; ..\..\mt\mt_util
  OBJCOPY.OOCOutputFile: STM32F103_Demo.srec
  ILINK.IlinkOutputFile: STM32F103_Demo.out
  ILINK.IlinkIcfFile: stm32f103xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../../user/: main.c stm32f10x_conf.h stm32f10x_it.c
  group CMSIS
    ../../user/: system_stm32f10x.c
  group EWARM
    ../../cmsis/startup/: startup_stm32f10x_hd.s
  group MT/mt_Alogrithm
    ../../mt/mt_alogrithm/: mt_alog_imu.c
  group MT/mt_App
    ../../mt/mt_app/: app_softwaretimer.c mt_app.c mt_app_gesture.c mt_app_led.c
  group MT/mt_Drv
    ../../mt/mt_drv/: mt_drv.c mt_drv_exti.c mt_drv_iic.c mt_drv_led.c mt_drv_rcc.c mt_drv_spi.c mt_drv_systick.c mt_drv_timer.c mt_drv_uart.c
  group MT/mt_Drv/module
    ../../mt/mt_drv/module/: mt_module.h
  group MT/mt_Drv/module/APDS_9960
    ../../mt/mt_drv/module/APDS_9960/: apds_9960.c apds_9960.h
  group MT/mt_Drv/module/LSM6DSL
    ../../mt/mt_drv/module/LSM6DSL/: mt_drv_lsm6dsl.c mt_drv_lsm6dsl.h
  group MT/mt_Hal
    ../../mt/mt_hal/: mt_hal.c mt_hal_led.c mt_hal_lsm6dsl.c mt_hal_nvic.c
  group STM32F10x_FWlib
    ../../stm32f10x_stdlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
